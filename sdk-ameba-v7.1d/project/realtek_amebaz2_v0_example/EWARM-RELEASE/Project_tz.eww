<?xml version="1.0" encoding="UTF-8"?>
<workspace>
	<project>
        <path>$WS_DIR$\application_ns.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\application_s.ewp</path>
    </project>
    <batchBuild />
</workspace>
